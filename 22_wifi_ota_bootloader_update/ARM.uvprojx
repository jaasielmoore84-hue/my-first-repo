# Keil uVision project ARM.uvprojx, settings and files
target ARM (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ARM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\App;.\Arm_kernel;.\Driver;.\GD32_lib;.\GD32_lib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group App
    ./App/: main.c store_app.c
  group Driver
    ./Driver/: delay.c usb2com_drv.c led_drv.c iap_drv.c inflash_drv.c md5.c
  group Arm_kernel
    ./Arm_kernel/: startup_gd32f30x_hd.s system_gd32f30x.c
  group GD32_lib
    ./GD32_lib/Source/: gd32f30x_gpio.c gd32f30x_rcu.c gd32f30x_misc.c gd32f30x_usart.c gd32f30x_fmc.c
